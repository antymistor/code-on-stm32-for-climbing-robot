# Keil uVision project A_Car_code.uvprojx, settings and files
target Nlict_Test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: A_Car_code +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\FWLIB\inc;.\HARDWARE;..\Nlict_Test;.\USER;.\SYSTEM\usart;.\SYSTEM\sys
  asm include: .\SYSTEM\sys;.\SYSTEM\delay;.\SYSTEM\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ./HARDWARE/: MYMISC.c MOTO_CTR.c SSI_HAE.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_pwr.c stm32f10x_bkp.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group read_me
    ./: Pin_Config.txt
  group SYSTEM
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/sys/: sys.c
